## wifi_shell/config/Kconfig
```kconfig
source "Kconfig.zephyr"
source "$(ZEPHYR_BASE)/samples/subsys/usb/common/Kconfig.sample_usbd"
```
